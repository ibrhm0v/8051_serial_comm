ORG 0000H
	LJMP 0800H
ORG 0800H
	MOV R0,#7FH
	CLR A
	MOV @R0,A
	DJNZ R0,0FDH
	MOV 81H,#10H
	LJMP 0847H
	LJMP 08E0H
	CLR A
	MOVC A,@A+DPTR
	INC DPTR
	MOV R0,A
	CLR A
	MOVC A,@A+DPTR
	INC DPTR
	JC 03H
	MOV @R0,A
	SJMP 01H
	MOVX @R0,A
	INC R0
	DJNZ R7,0F4H
	SJMP 29H
	CLR A
	MOVC A,@A+DPTR
	INC DPTR
	MOV R0,A
	ANL A,#07H
	ADD A,#0CH
	XCH A,R0
	CLR C
	RLC A
	SWAP A
	ANL A,#0FH
	ORL A,#20H
	XCH A,R0
	MOVC A,@A+PC
	JC 04H
	CPL A
	ANL A,@R0
	SJMP 01H
	ORL A,@R0
	MOV @R0,A
	DJNZ R7,0E4H
	SJMP 0BH
	AJMP 002H
	INC A
	INC R0
	JBC 20H,40H
	SJMP 90H
	INC R1
	PUSH 0E4H
	MOV R6,#01H
	MOVC A,@A+DPTR
	JZ 0BCH
	INC DPTR
	MOV R7,A
	ANL A,#3FH
	JNB 0E5H,09H
	ANL A,#1FH
	MOV R6,A
	CLR A
	MOVC A,@A+DPTR
	INC DPTR
	JZ 01H
	INC R6
	XCH A,R7
	ANL A,#0C0H
	ADD A,0E0H
	JZ 0A8H
	JC 0B8H
	CLR A
	MOVC A,@A+DPTR
	INC DPTR
	MOV R2,A
	CLR A
	MOVC A,@A+DPTR
	INC DPTR
	MOV R0,A
	CLR A
	MOVC A,@A+DPTR
	INC DPTR
	XCH A,R0
	XCH A,82H
	XCH A,R0
	XCH A,R2
	XCH A,83H
	XCH A,R2
	MOVX @DPTR,A
	INC DPTR
	XCH A,R0
	XCH A,82H
	XCH A,R0
	XCH A,R2
	XCH A,83H
	XCH A,R2
	DJNZ R7,0E9H
	DJNZ R6,0E7H
	SJMP 0BEH
	JNC 6CH
	XRL A,61H
	JMP @A+DPTR
	XRL A,20H
	JMP @A+DPTR
	XRL A,74H
	JB 79H,6FH
	MOV 72H,#20H
	XRL 61H,A
	MOV 64H,#72H
	AJMP 374H
	XRL A,20H
	MOV @R0,#69H
	AJMP 320H
	ANL 57H,#37H
	JB 28H,30H
	ADDC A,R2
	JB 39H,36H
	JNB 30H,2CH
	JB 31H,3AH
	JB 31H,39H
	RETI
	JNB 30H,29H
	ADD A,R6
	JB 54H,68H
	XRL A,6EH
	JB 70H,72H
	XRL A,73H
	JMP @A+DPTR
	JB 62H,75H
	MOV A,#74H
	XRL A,R7
	XRL A,R6
	JB 6FH,6EH
	JB 70H,6FH
	ORL C,74H
	JB 32H,2EH
	ADDC A,@R0
	NOP
	MOV 89H,#20H
	MOV 8DH,#0FDH
	MOV 98H,#50H
	SETB 8EH
	CLR A
	MOV 90H,A
	MOV 0A0H,#0FFH
	MOV R3,0EH
	MOV R2,0FH
	MOV R1,10H
	LCALL 09ABH
	MOV R4,06H
	MOV R5,07H
	MOV R3,0EH
	MOV R2,0FH
	MOV R1,10H
	LCALL 0973H
	MOV A,0A0H
	ANL A,#40H
	JZ 0FAH
	MOV A,0A0H
	ANL A,#80H
	JNZ 05H
	ANL 87H,#7FH
	SJMP 03H
	ORL 87H,#80H
	MOV 08H,90H
	MOV R3,#00H
	MOV R2,#00H
	MOV R1,#08H
	MOV R5,#01H
	MOV R4,#00H
	LCALL 0973H
	SJMP 0EEH
	CJNE R3,#01H,0CH
	MOV A,82H
	ADD A,R1
	MOV 82H,A
	MOV A,83H
	ADDC A,R2
	MOV 83H,A
	MOVX A,@DPTR
	RET
	JNC 06H
	MOV A,R1
	ADD A,82H
	MOV R0,A
	MOV A,@R0
	RET
	CJNE R3,#0FEH,06H
	MOV A,R1
	ADD A,82H
	MOV R0,A
	MOVX A,@R0
	RET
	MOV A,82H
	ADD A,R1
	MOV 82H,A
	MOV A,83H
	ADDC A,R2
	MOV 83H,A
	CLR A
	MOVC A,@A+DPTR
	RET
	CJNE R3,#01H,06H
	MOV 82H,R1
	MOV 83H,R2
	MOVX A,@DPTR
	RET
	JNC 02H
	MOV A,@R1
	RET
	CJNE R3,#0FEH,02H
	MOVX A,@R1
	RET
	MOV 82H,R1
	MOV 83H,R2
	CLR A
	MOVC A,@A+DPTR
	RET
	MOV 09H,R3
	MOV 0AH,R2
	MOV 0BH,R1
	MOV 0CH,R4
	MOV 0DH,R5
	CLR A
	MOV R7,A
	MOV R6,A
	CLR C
	MOV A,R7
	SUBB A,0DH
	MOV A,0CH
	XRL A,#80H
	MOV R0,A
	MOV A,R6
	XRL A,#80H
	SUBB A,R0
	JNC 1BH
	MOV R3,09H
	MOV R2,0AH
	MOV R1,0BH
	MOV 82H,R7
	MOV 83H,R6
	LCALL 092DH
	MOV 99H,A
	JNB 99H,0FDH
	CLR 99H
	INC R7
	CJNE R7,#00H,01H
	INC R6
	SJMP 0D6H
	RET
	CLR A
	MOV R7,A
	MOV R6,A
	LCALL 095AH
	JZ 0CH
	INC R7
	MOV A,R7
	JNZ 01H
	INC R6
	INC R1
	MOV A,R1
	JNZ 0F2H
	INC R2
	SJMP 0EFH
	RET
	RR A
	INC R6
	MOV R7,A
	INC R0
	MOV 00H,R4
	END
